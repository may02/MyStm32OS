# Keil uVision project STM32-BHS-OS.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
  group APP
    ./: app.c vectors.s
  group BSP
    ../BSP/: bsp.c init.s bsp_int.c
  group FWLib
    ../: STM32F10xR.LIB
  group FWSource
    D:/Keil/ARM/RV31/LIB/ST/STM32F10x/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC-CPU
    ../uC-CPU/ARM-Cortex-M3/: cpu_a.asm cpu_c.c
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Port
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-LIB
    ../uC-LIB/: lib_mem.c lib_str.c
    ../uC-LIB/Ports/: lib_mem_a.asm
  group usart
    ../usart/: Com.c
  group Documentation
    ./: readme.txt
  group TFT
    ../TFT/: LCD_driver.c
target RAM (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: STM32
  c flags: Optim=2 oTime=1 OneElfS=1 wLevel=2
  c define: "VECT_TAB_RAM"
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x2000
  scatter file: ..\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
